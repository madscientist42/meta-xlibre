# Flesh out the package with the baseline.  This file is the .bb entry
# point for this package and the version info, etc.
require xlibre-server.inc

# Grab our official version...
XLIBRE_BRANCH = "release/25.1"
SRCREV = "215e849a0a27b9da710f694e890846569a084fd9"
LIC_FILES_CHKSUM = "file://COPYING;md5=b2636b4caedb65bffd833b33ac98bfcf"
